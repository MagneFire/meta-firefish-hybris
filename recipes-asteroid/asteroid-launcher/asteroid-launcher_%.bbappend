FILESEXTRAPATHS_prepend_firefish := "${THISDIR}/asteroid-launcher:"
SRC_URI_append_firefish = " file://default.conf"
