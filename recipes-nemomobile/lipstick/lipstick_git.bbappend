RDEPENDS_${PN}_append_firefish = " qt5-qpa-hwcomposer-plugin "
