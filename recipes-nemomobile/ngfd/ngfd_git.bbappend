RDEPENDS_${PN}_append_firefish = " ngfd-plugin-droid-vibrator "
